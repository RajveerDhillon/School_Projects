# Keil uVision project finalproject_mediacenter.uvproj, settings and files
target LPC1700 (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: finalproject_mediacenter
  c flags: Optim=1
  c define: __ADC_IRQ
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Source Code
    ./: core_cm3.c GLCD_SPI_LPC1700.c IRQ.c LED.c KBD.c Media_Center.c
  group Image Files
    ./: monsterhunter.c SSBU.c zelda.c death_stranding.c
  group Media Center
    ./: Photo_Gallery.c Photo_Viewer.c
  group Audio
    ./: usbdmain.c adcuser.c usbcore.c usbdesc.c usbhw.c usbuser.c
  group Game
    ./: Game.c playertank.c blacccc.c enemydown.c enemyleft.c enemyright.c enemyup.c playerdown.c playerleft.c playerup.c Game.h
